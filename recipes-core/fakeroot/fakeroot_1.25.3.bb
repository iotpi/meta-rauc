include fakeroot.inc

SRC_URI[md5sum] = "f6104ef6960c962377ef062bf222a1d2"
SRC_URI[sha1sum] = "b6cb435df8d83ed2d8335b949e52b834122e4994"

